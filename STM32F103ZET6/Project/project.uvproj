# Keil uVision project project.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\User;..\App\DHT11;..\App\SysTick;..\App\printf;..\App\adc;..\App\AT24Cxx;..\App\beep;..\App\button;..\App\can;..\App\dac;..\App\delay;..\App\dma;..\App\DS18B20;..\App\exti;..\App\gui;..\App\HH_06;..\App\IIC(24C02);..\App\iwdg;..\App\lcd;..\App\led;..\App\rs485;..\App\rtc;..\App\spi;..\App\sys;..\App\tim;..\App\tpad;..\App\tsensor;..\App\usart;..\App\W25QXX;..\App\wkup;..\App\wwdg;..\App\ZPH01;..\Libraries\CMSIS\startup;..\App\timer;..\App\image2lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../App/DHT11/: dht11.c
    ../App/delay/: delay.c
    ../App/sys/: sys.c
    ../App/ZPH01/: zph01.c
    ../App/usart/: usart.c
    ../App/lcd/: lcd.c
    ../App/led/: LED.C
    ../App/timer/: time.c
    ../App/image2lcd/: image2lcd.c swpu.c gongjiaoe.c HzLib_65k.c
  group Startup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group Cmsis
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Fwlib
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Doc
    ../Doc/: GPIO管脚及功能定义.txt
